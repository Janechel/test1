# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=9
  c include: D:\STC89C52_SDK;.\.idea;D:\STC89C52_SDK;..\..\src;..\..\src;..\..\..\C
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c
